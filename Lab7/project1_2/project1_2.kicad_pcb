# Repository Praeiss/EE201

File README.md:

# Hello my name is Parsa

## I am a third year studying **Electrical Engineering** focusing on the embedded systems pathway.

## KiCad design Lab7/project1_2/project1_2.kicad_pcb

Board: 2 copper layers, 10 parts (0 on the bottom side), 8 nets.

Parts:
C1: 10microF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C2: 0.01microF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: Conn_01x02_Male; TerminalBlock_bornier-2_P5.08mm
R1, R3, R4: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: NE555D; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm

Connections:
+9V: D1.2 (A), J1.1, R1.1, U1.8 (VCC)
GND: C1.2, C2.2, D2.1 (K), J1.2, U1.1 (GND)
unnamed: C1.1, R2.2, U1.6 (THR)
unnamed: C2.1, U1.5 (CV)
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), R4.2
unnamed: R1.2, R2.1, U1.7 (DIS)
unnamed: R3.2, R4.1

## KiCad design Lab6/project1/project1.kicad_pcb

Board: 2 copper layers, 116.8 x 45.7 mm, 6 parts (0 on the bottom side), 5 nets.

Parts:
C1: 4.7microF; C_Radial_D5.0mm_H5.0mm_P2.00mm
D1: D; LED_D5.0mm
R1: 20kOhms; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
R2: 2.2kOhms; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
SW1: SW_SPDT; SW_E-Switch_EG1224_SPDT_Angled
V1: 9V; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical

Connections:
unnamed: C1.2, D1.1 (K), V1.2
unnamed: D1.2 (A), R1.2
unnamed: R2.1, SW1.2 (B)
unnamed: R2.2, V1.1
unnamed: C1.1, R1.1, SW1.3 (C)

## Commit log

2023-01-12 i created a readme file
2023-01-12 test
